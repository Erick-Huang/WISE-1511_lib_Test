# Keil uVision project wise-1511.uvprojx, settings and files
target wise-1511 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L433VCIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wise-1511 +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DMBED_BUILD_TIMESTAMP=1479263157.58 -DTARGET_ADVANTECH --restrict -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_SERIAL_FC=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --multibyte_chars --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -DARM_MATH_CM4 -DTARGET_CORTEX_M -DTARGET_WISE -DDEVICE_I2C=1 -D__CORTEX_M4 -DDEVICE_LOWPOWERTIMER=1 --brief_diagnostics -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DTOOLCHAIN_ARM -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_WISE1511 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .;./proj;./mbed-os;./mbed-os/targets;./mbed-os/targets/TARGET_ADVANTECH;./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE;./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/device;./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/TARGET_WISE1511;./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/TARGET_WISE1511/device;./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/TARGET_WISE1511/device/TOOLCHAIN_ARM_STD;./mbed-os/drivers;./mbed-os/events;./mbed-os/events/equeue;./mbed-os/docs;./mbed-os/cmsis;./mbed-os/hal;./mbed-os/hal/hal;./mbed-os/hal/storage_abstraction;./mbed-os/features;./mbed-os/features/frameworks;./mbed-os/features/frameworks/unity;./mbed-os/features/frameworks/unity/unity;./mbed-os/features/frameworks/unity/source;./mbed-os/features/frameworks/utest;./mbed-os/features/frameworks/utest/utest;./mbed-os/features/frameworks/utest/source;./mbed-os/features/frameworks/greentea-client;./mbed-os/features/frameworks/greentea-client/greentea-client;./mbed-os/features/frameworks/greentea-client/source;./mbed-os/features/nanostack;./mbed-os/features/mbedtls;./mbed-os/features/mbedtls/src;./mbed-os/features/mbedtls/importer;./mbed-os/features/mbedtls/inc;./mbed-os/features/mbedtls/inc/mbedtls;./mbed-os/features/mbedtls/platform;./mbed-os/features/mbedtls/platform/src;./mbed-os/features/mbedtls/platform/inc;./mbed-os/features/netsocket;./mbed-os/features/storage;./mbed-os/rtos;./mbed-os/rtos/rtx;./mbed-os/rtos/rtx/TARGET_CORTEX_M;./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7;./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM;./mbed-os/platform;.\mbed-os\targets\TARGET_STM\TARGET_STM32L4\TARGET_CUSTOM_L443RC\device;.\mbed-os\targets\TARGET_STM\TARGET_STM32L4;.\mbed-os\targets\TARGET_STM\TARGET_STM32L4\TARGET_CUSTOM_L443RC;.\mbed-os\targets\TARGET_STM\TARGET_STM32L4\device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/TARGET_WISE1511/device/TOOLCHAIN_ARM_STD/stm32l443xx.sct
  group equeue
    ./mbed-os/events/equeue/: equeue_platform.h equeue.h equeue.c equeue_posix.c equeue_mbed.cpp
  group TARGET_ADVANTECH
    ./mbed-os/targets/TARGET_STM/: mbed_rtx.h trng_api.c stm_spi_api.c
  group greentea-client
    ./mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
  group cmsis
    ./mbed-os/cmsis/: core_caFunc.h core_caInstr.h core_cmFunc.h core_cmInstr.h core_cm0plus.h core_cm7.h core_cm4.h core_cm0.h core_sc000.h core_cmSimd.h core_cmSecureAccess.h core_cm4_simd.h core_sc300.h arm_const_structs.h arm_common_tables.h core_ca_mmu.h core_ca9.h core_cm3.h arm_math.h
  group utest
    ./mbed-os/features/frameworks/utest/utest/: utest_serial.h utest_case.h utest_shim.h utest_scheduler.h utest_types.h utest.h unity_handler.h utest_stack_trace.h utest_harness.h utest_specification.h utest_default_handlers.h
    ./mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
  group mbedtls
    ./mbed-os/features/mbedtls/inc/mbedtls/: net_sockets.h sha256.h platform_time.h asn1.h pk.h bn_mul.h ssl.h gcm.h bignum.h ripemd160.h threading.h arc4.h ssl_internal.h havege.h hmac_drbg.h ctr_drbg.h x509_csr.h cmac.h x509.h net.h entropy_poll.h md4.h config-no-entropy.h md2.h version.h aes.h check_config.h error.h ecjpake.h pkcs11.h debug.h timing.h x509_crl.h pkcs12.h blowfish.h sha1.h base64.h ecp.h ssl_ciphersuites.h md_internal.h md.h pem.h rsa.h ssl_cache.h cipher.h x509_crt.h memory_buffer_alloc.h padlock.h asn1write.h pk_internal.h ccm.h pkcs5.h md5.h ecdh.h oid.h certs.h des.h config.h camellia.h cipher_internal.h entropy.h ssl_ticket.h ecdsa.h sha512.h aesni.h xtea.h platform.h ssl_cookie.h dhm.h compat-1.3.h
  group inc
    ./mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group hal
    ./mbed-os/hal/: serial_api.h sleep_api.h dma_api.h can_api.h lp_ticker_api.h analogout_api.h gpio_irq_api.h port_api.h ethernet_api.h buffer.h spi_api.h can_helper.h us_ticker_api.h pwmout_api.h gpio_api.h analogin_api.h trng_api.h i2c_api.h pinmap.h rtc_api.h ticker_api.h mbed_lp_ticker_api.c mbed_gpio.c mbed_us_ticker_api.c mbed_ticker_api.c mbed_pinmap_common.c
    ./mbed-os/hal/hal/: emac_api.h
  group netsocket
    ./mbed-os/features/netsocket/: nsapi_dns.h SocketAddress.h TCPSocket.h WiFiAccessPoint.h nsapi.h NetworkStack.h NetworkInterface.h nsapi_types.h emac_stack_mem.h Socket.h EthInterface.h MeshInterface.h UDPSocket.h CellularInterface.h WiFiInterface.h TCPServer.h nsapi_dns.cpp TCPServer.cpp NetworkInterface.cpp Socket.cpp NetworkStack.cpp TCPSocket.cpp WiFiAccessPoint.cpp UDPSocket.cpp SocketAddress.cpp
  group TARGET_CORTEX_M
    ./mbed-os/rtos/rtx/TARGET_CORTEX_M/: rt_Mutex.h rt_Memory.h rt_HAL_CM.h rt_Time.h cmsis_os.h RTX_CM_lib.h rt_Task.h rt_Event.h rt_System.h rt_OsEventObserver.h RTX_Config.h rt_Mailbox.h rt_TypeDef.h rt_List.h rt_Robin.h rt_Timer.h rt_Semaphore.h rt_MemBox.h rt_OsEventObserver.c RTX_Conf_CM.c rt_Time.c rt_Semaphore.c rt_Timer.c rt_Memory.c rt_Event.c rt_Mailbox.c HAL_CM.c rt_Mutex.c rt_System.c rt_CMSIS.c rt_List.c rt_Task.c rt_Robin.c rt_MemBox.c
  group rtos
    ./mbed-os/rtos/: Queue.h Semaphore.h rtos_idle.h MemoryPool.h RtosTimer.h Mail.h Thread.h rtos.h Mutex.h rtos_idle.c RtosTimer.cpp Thread.cpp Semaphore.cpp Mutex.cpp
  group platform
    ./mbed-os/platform/: mbed_mem_trace.h FunctionPointer.h PlatformMutex.h CallChain.h rtc_time.h mbed_assert.h critical.h CircularBuffer.h mbed_debug.h wait_api.h mbed_stats.h mbed_interface.h CThunk.h semihost_api.h Callback.h mbed_error.h SingletonPtr.h platform.h Transaction.h toolchain.h mbed_board.c mbed_assert.c mbed_mem_trace.c mbed_critical.c mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_error.c mbed_interface.c retarget.cpp mbed_alloc_wrappers.cpp CallChain.cpp mbed_wait_api_rtos.cpp mbed_rtc_time.cpp
  group unity
    ./mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group events
    ./mbed-os/events/: mbed_events.h Event.h EventQueue.h EventQueue.cpp
  group TARGET_WISE1511
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_CUSTOM_L443RC/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h PortNames.h
  group wise-1511
    ./: mbed_config.h main.cpp
  group mbed-os
    ./mbed-os/: mbed.h
  group device
    ./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/device/: stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_dma.h stm32l4xx_hal_spi.h stm32l4xx_ll_adc.h stm32l4xx_hal_lcd.h stm32l4xx_ll_i2c.h stm32l4xx_hal_flash.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_rtc.h stm32l4xx_hal_i2c_ex.h stm32l4xx_ll_dma.h stm32l4xx_ll_rng.h stm32l4xx_hal_sd.h stm32l4xx_hal_sram.h stm32_hal_legacy.h stm32l4xx_hal_firewall.h stm32l4xx_hal_nor.h stm32l4xx_ll_rcc.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_usart.h stm32l4xx_hal_sai.h stm32l4xx_hal_pwr_ex.h stm32l4xx_ll_usb.h stm32l4xx_hal_gpio.h stm32l4xx_hal_pwr.h stm32l4xx_ll_wwdg.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_rcc.h stm32l4xx_ll_spi.h stm32l4xx_hal_uart.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_uart_ex.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_rtc.h stm32l4xx_ll_iwdg.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_pcd_ex.h stm32l4xx_ll_bus.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_tim.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_pcd.h stm32l4xx_hal.h stm32l4xx_hal_lptim.h stm32l4xx_hal_irda.h stm32l4xx_ll_opamp.h stm32l4xx_hal_opamp.h stm32l4xx_hal_wwdg.h stm32l4xx_hal_cortex.h stm32l4xx_ll_pwr.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_swpmi.h stm32l4xx_hal_crc.h stm32l4xx_hal_tsc.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_i2c.h stm32l4xx_hal_irda_ex.h stm32l4xx_ll_utils.h stm32l4xx_ll_gpio.h stm32l4xx_ll_lptim.h stm32l4xx_hal_opamp_ex.h stm32l4xx_ll_cortex.h stm32l4xx_hal_swpmi.h stm32l4xx_ll_tim.h stm32l4xx_ll_system.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_cryp.h stm32l4xx_hal_qspi.h stm32l4xx_ll_usart.h stm32l4xx_hal_nand.h stm32l4xx_hal_can.h stm32l4xx_ll_dac.h stm32l4xx_hal_def.h stm32l4xx_ll_fmc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_ll_crs.h stm32l4xx_ll_comp.h stm32l4xx_hal_comp.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_adc.h stm32l4xx_ll_exti.h stm32l4xx_ll_crc.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_rcc.c stm32l4xx_ll_exti.c stm32l4xx_hal_rng.c stm32l4xx_ll_i2c.c stm32l4xx_hal_sram.c stm32l4xx_hal_dma.c stm32l4xx_hal_dfsdm.c stm32l4xx_ll_rng.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_ll_lptim.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_cortex.c stm32l4xx_ll_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_usart.c stm32l4xx_ll_opamp.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_opamp.c stm32l4xx_hal_hcd.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_ll_gpio.c stm32l4xx_hal_irda.c stm32l4xx_hal_dac.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_spi.c stm32l4xx_hal_cryp_ex.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c stm32l4xx_hal_comp.c stm32l4xx_hal_can.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_crs.c stm32l4xx_hal_nor.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_iwdg.c stm32l4xx_ll_tim.c stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_ll_dac.c stm32l4xx_ll_usart.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_smartcard.c stm32l4xx_ll_comp.c stm32l4xx_hal_qspi.c stm32l4xx_ll_adc.c stm32l4xx_hal_smbus.c stm32l4xx_hal_lptim.c stm32l4xx_hal_crc.c stm32l4xx_hal_lcd.c stm32l4xx_ll_swpmi.c stm32l4xx_hal_firewall.c stm32l4xx_ll_spi.c stm32l4xx_hal_sai.c stm32l4xx_ll_pwr.c stm32l4xx_ll_fmc.c stm32l4xx_hal_tsc.c stm32l4xx_ll_rtc.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_crc.c stm32l4xx_ll_dma.c stm32l4xx_hal_cryp.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_nand.c stm32l4xx_ll_lpuart.c stm32l4xx_hal_pcd.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
    ./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/TARGET_WISE1511/device/: stm32l443xx.h stm32l4xx.h stm32l4xx_hal_conf.h cmsis_nvic.h system_stm32l4xx.h hal_tick.h system_stm32l4xx.c hal_tick.c cmsis_nvic.c
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_CUSTOM_L443RC/device/: cmsis.h
  group src
    ./mbed-os/features/mbedtls/src/: dhm.c aes.c asn1parse.c ctr_drbg.c md5.c pem.c x509write_csr.c blowfish.c certs.c x509write_crt.c entropy_poll.c ecdsa.c x509_crt.c ccm.c arc4.c version.c camellia.c padlock.c ecp_curves.c md_wrap.c ssl_cookie.c bignum.c md.c pkparse.c cmac.c hmac_drbg.c error.c aesni.c pkcs12.c x509_csr.c memory_buffer_alloc.c pk_wrap.c ecdh.c pkcs11.c ssl_ciphersuites.c sha256.c sha512.c x509_crl.c version_features.c des.c havege.c entropy.c cipher_wrap.c x509.c base64.c threading.c ssl_ticket.c md4.c md2.c platform.c pkwrite.c cipher.c oid.c ssl_srv.c timing.c ssl_tls.c sha1.c pk.c gcm.c debug.c rsa.c xtea.c ssl_cli.c ecp.c net_sockets.c ssl_cache.c x509_create.c ecjpake.c ripemd160.c asn1write.c pkcs5.c
    ./mbed-os/features/mbedtls/platform/src/: mbed_trng.c
  group TARGET_WISE
    ./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/: gpio_object.h device.h common_objects.h rtc_api_hal.h PeripheralPins.h pinmap.c rtc_api.c port_api.c gpio_irq_api.c serial_api.c spi_api.c i2c_api.c can_api.c mbed_overrides.c us_ticker.c sleep.c lp_ticker.c analogout_api.c analogin_api.c pwmout_api.c gpio_api.c
  group storage_abstraction
    ./mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group source
    ./mbed-os/features/frameworks/unity/source/: unity.c
    ./mbed-os/features/frameworks/utest/source/: utest_default_handlers.cpp utest_case.cpp unity_handler.cpp utest_stack_trace.cpp utest_types.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp
    ./mbed-os/features/frameworks/greentea-client/source/: greentea_serial.cpp greentea_metrics.cpp test_env.cpp
  group TOOLCHAIN_ARM
    ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM4.c
  group TOOLCHAIN_ARM_STD
    ./mbed-os/targets/TARGET_ADVANTECH/TARGET_WISE/TARGET_WISE1511/device/TOOLCHAIN_ARM_STD/: startup_stm32l443xx.S sys.cpp
  group drivers
    ./mbed-os/drivers/: AnalogOut.h LocalFileSystem.h DigitalInOut.h FileSystemLike.h PortInOut.h LowPowerTimer.h LowPowerTicker.h Timeout.h I2C.h InterruptManager.h CAN.h Timer.h FilePath.h DigitalOut.h BusIn.h Ethernet.h SerialBase.h Serial.h Stream.h FileLike.h AnalogIn.h FileBase.h PortIn.h BusOut.h SPI.h InterruptIn.h LowPowerTimeout.h I2CSlave.h PortOut.h TimerEvent.h DirHandle.h BusInOut.h DigitalIn.h Ticker.h PwmOut.h SPISlave.h FileHandle.h RawSerial.h Serial.cpp FilePath.cpp CAN.cpp Ticker.cpp AnalogIn.cpp Timeout.cpp SerialBase.cpp InterruptIn.cpp FileLike.cpp BusIn.cpp Ethernet.cpp I2CSlave.cpp I2C.cpp Timer.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp TimerEvent.cpp BusInOut.cpp FileSystemLike.cpp FileBase.cpp Stream.cpp BusOut.cpp SPISlave.cpp SPI.cpp
